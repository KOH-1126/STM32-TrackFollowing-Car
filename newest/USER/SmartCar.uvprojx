# Keil uVision project SmartCar.uvprojx, settings and files
target demo (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: htdemo +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=5 wLevel=3
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\CMSIS;..\StdPeriph_Driver\inc;..\StdPeriph_Driver\src;..\USMART;.\;..\HARDWARE\ESP8266;..\HARDWARE\INTERFACE;..\HARDWARE\IRRC;..\HARDWARE\KEY;..\HARDWARE\MOTOR;..\HARDWARE\MPU6050;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\OLED;..\HARDWARE\SPEED;..\HARDWARE\Ultrasonic;..\MALLOC;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\USART;..\HARDWARE\OV7670;..\HARDWARE\TIMER;..\HARDWARE\EXTI;..\HARDWARE\EasyTracer;C:\Keil_v5\ARM\ARMCC\include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.h main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ./: startup_stm32f10x_hd.s
  group MALLOC
    ../MALLOC/: malloc.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/USART/: usart.c usart3.c
  group HARDWARE
    ../HARDWARE/ESP8266/: common.c wifista.c
    ../HARDWARE/INTERFACE/: interface.c
    ../HARDWARE/IRRC/: IRCtrol.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/MOTOR/: motor.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/OLED/: OLED_Driver.c
    ../HARDWARE/SPEED/: SpeedCtrol.c
    ../HARDWARE/Ultrasonic/: UltrasonicCtrol.c
    ../HARDWARE/OV7670/: ov7670.c sccb.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/EXTI/: exti.c
software components: CMSIS:CORE 5.6.0
